# Keil uVision project lab1_ex1_B.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8031AH Intel
  cpu: IRAM(0-0x7F) CLOCK(12000000)
  output: lab1_ex1_B
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lab1_ex1_B.a51
